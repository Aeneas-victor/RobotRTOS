# Keil uVision project Template.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: .\User;.\Libraries\CMSIS;.\Libraries\STM32F10x_StdPeriph_Driver\inc;.\FreeRTOS\include;.\FreeRTOS\portable\RVDS\ARM_CM3;.\Hardware;.\System;.\ActionGroup;.\PCA9685
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup
    ./User/: startup_stm32f10x_md.s
  group StdPeriph_Driver
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_gpio.c stm32f10x_rcc.c misc.c stm32f10x_exti.c stm32f10x_tim.c stm32f10x_usart.c
  group CMSIS
    ./Libraries/CMSIS/: system_stm32f10x.c core_cm3.c
  group Hardware
    ./Hardware/: led.c led.h OLED.c OLED.h OLED_Font.h Exti.c Exti.h Timer.c Timer.h
  group System
    ./System/: system.c system.h SysTick.c SysTick.h usart.c usart.h sys.c sys.h
  group FreeRTOS_core
    ./FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS_port
    ./FreeRTOS/portable/MemMang/: heap_4.c
    ./FreeRTOS/portable/RVDS/ARM_CM3/: port.c
  group ActionGroup
    ./ActionGroup/: Action.c Action.h common.h rotation.c turn.c WavyGait.c FreeRTOS_Action.c freeRTOS_Action.h
  group PCA9685
    ./PCA9685/: Motor.c Motor.h myiic.c myiic.h PCA9685.c PCA9685.h PWM.c PWM.h servo.c servo.h TB6612.c TB6612.h
  group User
    ./User/: main.c stm32f10x_it.c Starrt_Init.c
